# Keil uVision project AT32.uvprojx, settings and files
target GM_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F415R8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RESISTOR_10K_TAB, AT32F415R8T7,USE_STDPERIPH_DRIVER
  c include: .\UTIL;.\VOS;.\MAIN;.\DRIVER;.\DEBUG;.\MODBUS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MAIN
    ./MAIN/: main.c
  group UTIL
    ./UTIL/: delay.c utils.c
  group VOS
    ./VOS/: task.c
  group DRIVER
    ./DRIVER/: 24cxx.c buzzer.c led.c myiic.c myspi.c myadc.c spi.c timer.c usart.c w25x16.c wdg.c ts06.c nrf24l01.c ss.c oled.c ertc.c infrade_r.c infrade_t.c ntc.c ds18b20.c
  group CONSOLE
    ./DEBUG/: log.c shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group MODBUS
    ./MODBUS/: mbs_drv.c mbs_func.c mbs_port.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:ERTC 1.0.1, Device:StdPeriph Drivers:EXTI 1.0.1, Device:StdPeriph Drivers:FMC 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:IWDG 1.0.1, Device:StdPeriph Drivers:PWR 1.0.1, Device:StdPeriph Drivers:RCC 1.0.1, Device:StdPeriph Drivers:SPI 1.0.1, Device:StdPeriph Drivers:TIMER 1.0.1, Device:StdPeriph Drivers:USART 1.0.1, Device:System_AT32Fxx 1.0.1
